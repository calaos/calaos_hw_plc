# Repository calaos/calaos_hw_plc (continued)

## KiCad design hw/calaos_plc_io/calaos_plc_io.kicad_pcb (continued)

Schematic: calaos_plc_io_inputs-1.sch, calaos_plc_io

Parts:
D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33: TVS 3v3; SOD-523
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: Q_NPN_BCE; SOT-23; Mouser Ref 863-MMBT2222ALT1G
R3, R4, R5, R6, R7, R8, R9, R10, R27, R28, R29, R30, R31, R32, R33, R34: 220; R_0603
R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R61, R62, R63, R64, R65, R76, R77, R78, R79, R80, R91, R92, R93, R94, R95, R98: 10k; R_0603
R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R96, R97: 390; R_0603
U6, U7, U8, U9, U10, U11, U12, U13: LTV-847; SOIC-16_3.9x9.9mm_Pitch1.27mm

Connections:
+5V: R61.1, R62.1, R63.1, R64.1, R65.1, R76.1, R77.1, R78.1, R79.1, R80.1, R91.1, R92.1, R93.1, R94.1, R95.1, R98.1; also elsewhere on the board
+24V: R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R49.1, R50.1; also elsewhere on the board
/Inputs-1/DI_01: R51.2; also elsewhere on the board
/Inputs-1/DI_02: R52.2; also elsewhere on the board
/Inputs-1/DI_03: R53.2; also elsewhere on the board
/Inputs-1/DI_04: R54.2; also elsewhere on the board
/Inputs-1/DI_05: R55.2; also elsewhere on the board
/Inputs-1/DI_06: R66.2; also elsewhere on the board
/Inputs-1/DI_07: R67.2; also elsewhere on the board
/Inputs-1/DI_08: R68.2; also elsewhere on the board
/Inputs-1/DI_09: R69.2; also elsewhere on the board
/Inputs-1/DI_10: R70.2; also elsewhere on the board
/Inputs-1/DI_11: R81.2; also elsewhere on the board
/Inputs-1/DI_12: R82.2; also elsewhere on the board
/Inputs-1/DI_13: R83.2; also elsewhere on the board
/Inputs-1/DI_14: R84.2; also elsewhere on the board
/Inputs-1/DI_15: R85.2; also elsewhere on the board
/Inputs-1/DI_16: R96.2; also elsewhere on the board
/Inputs-1/DO_01: Q1.2, R19.2; also elsewhere on the board
/Inputs-1/DO_02: Q2.2, R20.2; also elsewhere on the board
/Inputs-1/DO_03: Q3.2, R21.2; also elsewhere on the board
/Inputs-1/DO_04: Q4.2, R22.2; also elsewhere on the board
/Inputs-1/DO_05: Q5.2, R23.2; also elsewhere on the board
/Inputs-1/DO_06: Q6.2, R24.2; also elsewhere on the board
/Inputs-1/DO_07: Q7.2, R25.2; also elsewhere on the board
/Inputs-1/DO_08: Q8.2, R26.2; also elsewhere on the board
/Inputs-1/DO_09: Q9.2, R43.2; also elsewhere on the board
/Inputs-1/DO_10: Q10.2, R44.2; also elsewhere on the board
/Inputs-1/DO_11: Q11.2, R45.2; also elsewhere on the board
/Inputs-1/DO_12: Q12.2, R46.2; also elsewhere on the board
/Inputs-1/DO_13: Q13.2, R47.2; also elsewhere on the board
/Inputs-1/DO_14: Q14.2, R48.2; also elsewhere on the board
/Inputs-1/DO_15: Q15.2, R49.2; also elsewhere on the board
/Inputs-1/DO_16: Q16.2, R50.2; also elsewhere on the board
/Inputs-1/I_0: R61.2, U10.16
/Inputs-1/I_1: R62.2, U10.14
/Inputs-1/I_2: R63.2, U10.12
/Inputs-1/I_3: R64.2, U10.10
/Inputs-1/I_4: R65.2, U11.16
/Inputs-1/I_5: R76.2, U11.14
/Inputs-1/I_6: R77.2, U11.12
/Inputs-1/I_7: R78.2, U11.10
/Inputs-1/I_8: R79.2, U12.16
/Inputs-1/I_9: R80.2, U12.14
/Inputs-1/I_10: R91.2, U12.12
/Inputs-1/I_11: R92.2, U12.10
/Inputs-1/I_12: R93.2, U13.16
/Inputs-1/I_13: R94.2, U13.14
/Inputs-1/I_14: R95.2, U13.12
/Inputs-1/I_15: R98.2, U13.10
/Inputs-1/O_0: R3.2; also elsewhere on the board
/Inputs-1/O_1: R4.2; also elsewhere on the board
/Inputs-1/O_2: R5.2; also elsewhere on the board
/Inputs-1/O_3: R6.2; also elsewhere on the board
/Inputs-1/O_4: R7.2; also elsewhere on the board
/Inputs-1/O_5: R8.2; also elsewhere on the board
/Inputs-1/O_6: R9.2; also elsewhere on the board
/Inputs-1/O_7: R10.2; also elsewhere on the board
/Inputs-1/O_8: R27.2; also elsewhere on the board
/Inputs-1/O_9: R28.2; also elsewhere on the board
/Inputs-1/O_10: R29.2; also elsewhere on the board
/Inputs-1/O_11: R30.2; also elsewhere on the board
/Inputs-1/O_12: R31.2; also elsewhere on the board
/Inputs-1/O_13: R32.2; also elsewhere on the board
/Inputs-1/O_14: R33.2; also elsewhere on the board
/Inputs-1/O_15: R34.2; also elsewhere on the board
GND: U6.2, U6.4, U6.6, U6.8, U7.2, U7.4, U7.6, U7.8, U8.2, U8.4, U8.6, U8.8, U9.2, U9.4, U9.6, U9.8, U10.9, U10.11, U10.13, U10.15, U11.9, U11.11, U11.13, U11.15, U12.9, U12.11, U12.13, U12.15, U13.9, U13.11, U13.13, U13.15; also elsewhere on the board
GNDREF: D18.2, D19.2, D20.2, D21.2, D22.2, D23.2, D24.2, D25.2, D26.2, D27.2, D28.2, D29.2, D30.2, D31.2, D32.2, D33.2, Q1.3, Q2.3, Q3.3, Q4.3, Q5.3, Q6.3, Q7.3, Q8.3, Q9.3, Q10.3, Q11.3, Q12.3, Q13.3, Q14.3, Q15.3, Q16.3, U6.9, U6.11, U6.13, U6.15, U7.9, U7.11, U7.13, U7.15, U8.9, U8.11, U8.13, U8.15, U9.9, U9.11, U9.13, U9.15, U10.2, U10.4, U10.6, U10.8, U11.2, U11.4, U11.6, U11.8, U12.2, U12.4, U12.6, U12.8, U13.2, U13.4, U13.6, U13.8
unnamed: D18.1, R51.1, R56.2
unnamed: D19.1, R52.1, R57.2
unnamed: D20.1, R53.1, R58.2
unnamed: D21.1, R54.1, R59.2
unnamed: D22.1, R55.1, R60.2
unnamed: D23.1, R66.1, R71.2
unnamed: D24.1, R67.1, R72.2
unnamed: D25.1, R68.1, R73.2
unnamed: D26.1, R69.1, R74.2
unnamed: D27.1, R70.1, R75.2
unnamed: D28.1, R81.1, R86.2
unnamed: D29.1, R82.1, R87.2
unnamed: D30.1, R83.1, R88.2
unnamed: D31.1, R84.1, R89.2
unnamed: D32.1, R85.1, R90.2
unnamed: D33.1, R96.1, R97.2
unnamed: Q1.1, R11.2, U6.16
unnamed: Q2.1, R12.2, U6.14
unnamed: Q3.1, R13.2, U6.12
unnamed: Q4.1, R14.2, U6.10
unnamed: Q5.1, R15.2, U7.16
unnamed: Q6.1, R16.2, U7.14
unnamed: Q7.1, R17.2, U7.12
unnamed: Q8.1, R18.2, U7.10
unnamed: Q9.1, R35.2, U8.16
unnamed: Q10.1, R36.2, U8.14
unnamed: Q11.1, R37.2, U8.12
unnamed: Q12.1, R38.2, U8.10
unnamed: Q13.1, R39.2, U9.16
unnamed: Q14.1, R40.2, U9.14
unnamed: Q15.1, R41.2, U9.12
unnamed: Q16.1, R42.2, U9.10
unnamed: R3.1, U6.1
unnamed: R4.1, U6.3
unnamed: R5.1, U6.5
unnamed: R6.1, U6.7
unnamed: R7.1, U7.1
unnamed: R8.1, U7.3
unnamed: R9.1, U7.5
unnamed: R10.1, U7.7
unnamed: R27.1, U8.1
unnamed: R28.1, U8.3
unnamed: R29.1, U8.5
unnamed: R30.1, U8.7
unnamed: R31.1, U9.1
unnamed: R32.1, U9.3
unnamed: R33.1, U9.5
unnamed: R34.1, U9.7
unnamed: R56.1, U10.1
unnamed: R57.1, U10.3
unnamed: R58.1, U10.5
unnamed: R59.1, U10.7
unnamed: R60.1, U11.1
unnamed: R71.1, U11.3
unnamed: R72.1, U11.5
unnamed: R73.1, U11.7
unnamed: R74.1, U12.1
unnamed: R75.1, U12.3
unnamed: R86.1, U12.5
unnamed: R87.1, U12.7
unnamed: R88.1, U13.1
unnamed: R89.1, U13.3
unnamed: R90.1, U13.5
unnamed: R97.1, U13.7

Notes on the sheet:
30mA @ 24V 25mA @ 12V 5mA @ 5V => 35V -> 5V input with opto like LTV-847 ?

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
Board: 2 copper layers, 167 parts (103 on the bottom side), 149 nets, no tracks yet.
